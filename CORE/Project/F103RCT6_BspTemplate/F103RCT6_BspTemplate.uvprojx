# Keil uVision project F103RCT6_BspTemplate.uvprojx, settings and files
target F103C8T6_BspTemplate (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103RCT6_BspTemplate +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\beep;..\..\User\Key;..\..\User\usart;..\..\User\Timer;..\..\User\delay;..\..\User\GpioRemap;..\..\User\motor;..\..\User\oled\oled_I2C;..\..\User\APP;..\..\User\adc;..\..\User\lcd;..\..\User\servo;..\..\User\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Led/: bsp_led.c
    ../../User/beep/: bsp_beep.c
    ../../User/Key/: bsp_key.c
    ../../User/usart/: bsp_usart.c communication_protocol.c communication_protocol.h
    ../../User/delay/: bsp_delay.c
    ../../User/APP/: app.c
    ../../User/adc/: bsp_adc.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/servo/: servo.c
    ../../User/GpioRemap/: bsp_GpioRemap.c bsp_GpioRemap.h
    ../../User/motor/: Encoder.c Encoder.h PID.c PID.h Motor.c Motor.h
    ../../User/oled/oled_I2C/: OLED.c OLED.h OLED_Font.h
  group DOC
    ../../Doc/: readme.txt
